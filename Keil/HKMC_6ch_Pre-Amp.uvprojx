# Keil uVision project HKMC_6ch_Pre-Amp.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.3.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: output +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Core\Device\ABOV\A31G22x\Include;..\Core\CMSIS\Include;..\Drivers\Include;..\;..\a2bstack\a2bstack\include;..\a2bstack-pal\platform;..\a2bstack\a2bstack-protobuf\include;..\a2bstack-pal;..\app;..\a2bstack\a2bstack\include\a2b;..\a2bstack\a2bstack\source;..\a2bstack\a2bplugin-slave\include;..\a2bstack\a2bplugin-master\include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Drivers
    ../Drivers/Source/: A31G22x_hal_cfmc.c A31G22x_hal_i2c.c A31G22x_hal_pcu.c A31G22x_hal_scu.c A31G22x_hal_uartn.c A31G22x_hal_usart1n.c debug.c debug_cmd.c debug_frmwrk.c A31G22x_hal_timer2n.c A31G22x_hal_pwr.c
  group StartUp
    ../Core/Device/ABOV/A31G22x/Source/ARM/: startup_A31G22x.s
  group CMSIS_CM0plus
    ../Core/Device/ABOV/A31G22x/Source/: system_A31G22x.c
  group UserCode
    ../: A31G22x_it.c A31G22x_PortInit.c A31G22x_SystemClock.c i2c.c main.c ADAU1761.c ADAU1452.c timer20.c a2bapp.c
  group a2bstack
    ../a2bstack/a2bstack/source/: a2b_i2c.c audio.c diag.c gpio.c interrupt.c jobexec.c memmgr.c msg.c msgrtr.c pool.c seqchart.c stack.c stackctx.c stackctxmailbox.c stackinfo.c stringbuffer.c system.c timer.c trace.c util.c
  group a2bplugin-master
    ../a2bstack/a2bplugin-master/source/: a2b_bert.c a2bmaster_plugin.c a2bmaster_verinfo.c discovery.c override.c periphcfg.c periphutil.c pwrdiag.c
  group a2bplugin-slave
    ../a2bstack/a2bplugin-slave/source/: a2b_peri_config.c a2bslave_plugin.c a2bslave_verinfo.c
  group a2bplugin-protobuf
    ../a2bstack/a2bstack-protobuf/source/: a2b_bdd_helper.c bdd_pb2.pb.c pb_common.c pb_decode.c
  group app
    ../app/: adi_a2b_busconfig.c
  group a2bstack-pal
    ../a2bstack-pal/: adi_a2b_init.c adi_a2b_irq.c adi_a2b_pal.c
